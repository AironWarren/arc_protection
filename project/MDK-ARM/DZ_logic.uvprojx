# Keil uVision project DZ_logic.uvprojx, settings and files
target DZ_logic (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: DZ_logic +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F107xC
  c include: ../Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc;      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;      ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;      ../Drivers/CMSIS/Include;      ..\MIddleware\FreeModbus;      ..\MIddleware\FreeModbus\port;      ..\MIddleware\FreeModbus\port\no_os;      ..\MIddleware\FreeModbus\modbus;      ..\MIddleware\FreeModbus\modbus\tcp;      ..\MIddleware\FreeModbus\modbus\rtu;      ..\MIddleware\FreeModbus\modbus\include;      ..\MIddleware\FreeModbus\modbus\functions;      ..\MIddleware\FreeModbus\modbus\ascii;      ..\Bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f107xc.s
  group Application/User
    ../Src/: stm32f1xx_it.c stm32f1xx_hal_msp.c main.c
  group Middleware
    ../MIddleware/FreeModbus/port/: user_mb_app.c
    ../MIddleware/FreeModbus/port/no_os/: port.c portevent.c portserial.c porttimer.c
    ../MIddleware/FreeModbus/modbus/: mb.c
    ../MIddleware/FreeModbus/modbus/tcp/: mbtcp.c
    ../MIddleware/FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../MIddleware/FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../MIddleware/FreeModbus/modbus/ascii/: mbascii.c
  group BSP
    ../Bsp/: irq_callback.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_pwr.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
